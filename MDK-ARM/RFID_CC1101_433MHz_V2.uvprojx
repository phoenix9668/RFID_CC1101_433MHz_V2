# Keil uVision project RFID_CC1101_433MHz_V2.uvprojx, settings and files
target RFID_CC1101_433MHz_V2 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32L051C8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: RFID_CC1101_433MHz_V2 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32L051xx
  c include: ../Core/Inc;../Drivers/STM32L0xx_HAL_Driver/Inc;../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32l051xx.s
  group Application/User/Core
    ../Core/Src/: adxl362.c cc1101.c rand_bytes_gen.c main.c gpio.c adc.c crc.c iwdg.c rtc.c spi.c usart.c stm32l0xx_it.c stm32l0xx_hal_msp.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_ll_gpio.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_exti.c stm32l0xx_ll_rcc.c stm32l0xx_ll_utils.c stm32l0xx_ll_exti.c stm32l0xx_hal_crc.c stm32l0xx_hal_crc_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_ll_spi.c stm32l0xx_ll_dma.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_ll_usart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l0xx.c
software components: CMSIS:CORE 4.3.0
